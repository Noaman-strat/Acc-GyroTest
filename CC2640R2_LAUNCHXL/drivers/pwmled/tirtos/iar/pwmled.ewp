# IAR project pwmled.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: CC2640R2F TexasInstruments CC2640R2F
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.IExtraOptions: -I$PROJ_DIR$; -f$SIMPLELINK_CC2640R2_SDK_INSTALL_DIR$/kernel/tirtos/builds/CC2640R2_LAUNCHXL/release/iar/compiler.opt.defs; -DDeviceFamily_CC26X0R2; -I$SIMPLELINK_CC2640R2_SDK_INSTALL_DIR$/source; -I$SIMPLELINK_CC2640R2_SDK_INSTALL_DIR$/kernel/tirtos/packages/ti/sysbios/posix; --debug; --silent; -e; --aeabi; --thumb; --diag_suppress=Pa050
  ICCARM.CCIncludePath2: ..\..
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  prebuild: iarbuild.exe $SIMPLELINK_CC2640R2_SDK_INSTALL_DIR$/kernel/tirtos/builds/CC2640R2_LAUNCHXL/release/iar/tirtos_builds_CC2640R2_LAUNCHXL_release.ewp Debug -log all
  ILINK.IlinkOutputFile: pwmled.out
  ILINK.IlinkIcfFile: $PROJ_FNAME$_CC2640R2_LAUNCHXL_TIRTOS.icf
  ILINK.IlinkExtraOptions: -f$SIMPLELINK_CC2640R2_SDK_INSTALL_DIR$/kernel/tirtos/builds/CC2640R2_LAUNCHXL/release/iar/linker.cmd; $SIMPLELINK_CC2640R2_SDK_INSTALL_DIR$/source/ti/display/lib/display.arm3; $SIMPLELINK_CC2640R2_SDK_INSTALL_DIR$/source/ti/mw/lcd/lib/lcd.arm3; $SIMPLELINK_CC2640R2_SDK_INSTALL_DIR$/source/ti/grlib/lib/grlib.arm3; $SIMPLELINK_CC2640R2_SDK_INSTALL_DIR$/source/ti/drivers/rf/lib/rf_multiMode_cc26x0r2.arm3; $SIMPLELINK_CC2640R2_SDK_INSTALL_DIR$/source/ti/drivers/lib/drivers_cc26x0r2.arm3; $SIMPLELINK_CC2640R2_SDK_INSTALL_DIR$/source/ti/drivers/pdm/lib/pdm_cc26x0r2.arm3; $SIMPLELINK_CC2640R2_SDK_INSTALL_DIR$/kernel/tirtos/packages/ti/dpl/lib/dpl_cc26x0r2.arm3; $SIMPLELINK_CC2640R2_SDK_INSTALL_DIR$/source/ti/devices/cc26x0r2/driverlib/bin/iar/driverlib.lib; --silent; --cpu=Cortex-M3; --redirect; _Printf=_PrintfSmall; --redirect; _Scanf=_ScanfSmall
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group PWM LED/Documentation
    $SIMPLELINK_CC2640R2_SDK_INSTALL_DIR$/source/ti/blestack/boards/CC2640R2_LAUNCHXL/: Board.html
    ./: README.html README.md
  group PWM LED/Header files
    ./: Board.h CC2640R2_LAUNCHXL.h
  group PWM LED/Source files
    ./: CC2640R2_LAUNCHXL.c ccfg.c main_tirtos.c pwmled.c pwmled_CC2640R2_LAUNCHXL_TIRTOS.icf
